## app/boards/shields/quick_actions/Kconfig.defconfig
```kconfig
if SHIELD_QUICK_ACTIONS

config ZMK_KEYBOARD_NAME
	default "Quick Actions"

endif # SHIELD_QUICK_ACTIONS
```
